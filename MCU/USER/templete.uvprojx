# Keil uVision project templete.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\SYSTEM\sys;..\SYSTEM\connectFPGA;..\SYSTEM\spi;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\SYSTEM\rlcmeasure;..\HARDWARE\AD8865;..\HARDWARE\DA8811;..\HARDWARE\SPI;..\SYSTEM\ui;..\HARDWARE\TIMER;..\HARDWARE\OSCI;..\MALLOC;..\HARDWARE\SRAM;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO;..\HARDWARE\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYS
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/connectFPGA/: connectFPGA.c
    ../SYSTEM/rlcmeasure/: rlcmeasure.c
    ../SYSTEM/ui/: ui1.c
    ./: fft.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c lcdpro.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c ott2001a.c touch.c gt9147.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OSCI/: osci.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/DA8811/: dac8811.c
    ../HARDWARE/AD8865/: ads8865.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
